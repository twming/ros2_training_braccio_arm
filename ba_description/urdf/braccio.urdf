Commit message: Update braccio.urdf

File: ba_description/urdf/braccio.urdf (robot description, URDF)
Before this commit: robot braccio_arm, 9 links, 8 joints
Joints:
- joint gripper_movable: axis 0 -1 0 -> -1 0 0
